#
# Copyright (C)2024 KOAN sas - <https://koansoftware.com>
#

# change the NXP repo with the System Electronics custom one
UBOOT_SRC = "git://github.com/System-Electronics/uboot-sysele-imx;protocol=https"
SRCBRANCH = "lf-5.15.71-2.2.0-sysele"
SRCREV = "fe10f463de349023097472fe7d09e4c15f78c76d"

# set local version
LOCALVERSION = "-sysele"
