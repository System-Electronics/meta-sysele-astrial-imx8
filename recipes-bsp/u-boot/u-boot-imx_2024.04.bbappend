#
# Copyright (C)2024 KOAN sas - <https://koansoftware.com>
#

# change the NXP repo with the System Electronics custom one
UBOOT_SRC = "git://github.com/System-Electronics/uboot-sysele-imx;protocol=https"
SRCBRANCH = "lf-6.6.52-2.2.0-sysele"
SRCREV = "77769c27bb81dfa11601a2bb1da1f21ff688abe3"

# set local version
LOCALVERSION = "-sysele"
